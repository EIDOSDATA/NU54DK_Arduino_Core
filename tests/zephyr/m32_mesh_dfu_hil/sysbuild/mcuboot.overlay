/**
 * @file mcuboot.overlay
 * @brief M32 Mesh DFU HIL의 내부 flash boot partition을 선택합니다.
 *
 * SPDX-License-Identifier: MIT
 */

/ {
	chosen {
		zephyr,code-partition = &boot_partition;
	};
};
